PR = "r2"
CURLGNUTLS = " --without-gnutls --with-ssl"
